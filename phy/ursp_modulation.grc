options:
  parameters:
    generate_options: qt_gui
    id: moddemod
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: BPSK
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: header
  id: variable
  parameters:
    value: digital.header_format_default(key,0)
  states: {}
- name: key
  id: variable
  parameters:
    value: '"111000010101101010101010101110100010010011"'
  states: {}
- name: loop_bandwidth
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(gain=1.0, sampling_freq=samp_rate, symbol_rate=500000 , alpha=0.35, ntaps=101)
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/gnuradio/Documents/projet_wsn_dream_team/mac_frame.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '22'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: byte
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: BPSK
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: '4'
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: header
    len_tag_key: '"packet_len"'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: samp_rate/2
    center_freq0: '868000000'
    gain0: '70'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '1']
- [blocks_stream_to_tagged_stream_0, '0', digital_protocol_formatter_bb_0, '0']
- [blocks_tagged_stream_mux_0, '0', digital_constellation_modulator_0, '0']
- [digital_constellation_modulator_0, '0', uhd_usrp_sink_0, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0

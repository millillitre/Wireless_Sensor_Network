options:
  parameters:
    generate_options: qt_gui
    id: moddemod
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: BPSK
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: header
  id: variable
  parameters:
    value: digital.header_format_default(key,0)
  states: {}
- name: key
  id: variable
  parameters:
    value: '"111000010101101010101010101110100010010011"'
  states: {}
- name: loop_bandwidth
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(gain=1.0, sampling_freq=samp_rate, symbol_rate=500000 , alpha=0.35, ntaps=101)
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '2'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: BPSK
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: key
    tagname: '"packet_len"'
    threshold: '1'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: loop_bandwidth
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: '32'
    init_phase: '16'
    loop_bw: loop_bandwidth
    max_dev: '1.5'
    osps: '1'
    sps: '4'
    taps: taps
    type: ccf
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import struct
      import zlib

      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='MAC Decoder & Display',
                  in_sig=[np.uint8], # On reçoit des octets (char)
                  out_sig=None       # Pas de sortie vers un autre bloc
              )
              self.trame_size = 22
              self.buffer = bytearray()
              
              # Préparation de l'affichage (Console ou Fenêtre)
              print("\n" + "="*60)
              print(f"{'Trame':<8} | {'Addr':<6} | {'CowID':<8} | {'Lat':<10} | {'Long':<10} | {'Alt':<10} | {'CRC':<6}")
              print("-" * 60)

          def work(self, input_items, output_items):
              in_data = input_items[0]
              
              # Ajouter les nouvelles données au buffer
              self.buffer.extend(in_data.tobytes())

              # Tant qu'on a assez de données pour au moins une trame
              while len(self.buffer) >= self.trame_size:
                  trame = self.buffer[:self.trame_size]
                  self.buffer = self.buffer[self.trame_size:] # On vide ce qu'on a lu

                  try:
                      # Décodage identique à votre script
                      # Format: > (Big Endian) B(1) I(4) I(4) I(4) I(4) B(1) I(4)
                      # Note: Votre unpack original avait un espace "B I", ajusté ici en "BI"
                      res = struct.unpack(">BIIIIBI", trame)
                      address, cow_id, lat, lon, alt, padding, crc_rx = res

                      # Vérification CRC
                      crc_calc = zlib.crc32(trame[:-4]) & 0xFFFFFFFF
                      crc_ok = "OK" if crc_rx == crc_calc else "BAD"

                      # Affichage en temps réel dans le terminal de GNU Radio
                      print(f"RECUE    | {hex(address):<6} | {cow_id:<8} | {lat:<10} | {lon:<10} | {alt:<10} | {crc_ok:<6}")
                      
                  except Exception as e:
                      print(f"Erreur décodage: {e}")

              return len(in_data)
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: samp_rate/2
    center_freq0: '868000000'
    gain0: '50'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [blocks_repack_bits_bb_0, '0', epy_block_1, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_sink_x_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_costas_loop_cc_0, '0']
- [uhd_usrp_source_0, '0', analog_agc_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
